# Repository jy99/LittleBoards

File README.md:

This is a repository housing various embedded board designs, firmware, etc.
that I'm playing with.

## KiCad design LPC1114-dev-board/LPC1114-dev-board.kicad_pcb

File LPC1114-dev-board/README.md:

This is a design for a 2"x4" dev board for a through-hole version of the LPC1114 Cortex M0
processor with support for programming via SWD and the serial bootloader (not yet tested :-))

Parts:
C1: 220uF; c_elec_8x10
C2, C3: 16pF; c_0805
C4: 10uF; c_elec_8x10
C5, C6: 100nF; c_0805
C7: 0.1uF; c_0805
C8: 1uF; c_0805
CON1: DC IN; BARREL_JACK
D1: 1N4002; SMX-DIODE
K1: PWR_SEL; PIN_ARRAY_3X1
P1, P4: CONN_12; PIN_ARRAY-12X1
P2: SWD; PIN_ARRAY_5x2_2MM
P3: ISP/SERIAL; PIN_ARRAY-6X1
P5: PROG_RESET; PIN_ARRAY_2X1
R1: 330; SM0805
R2: 200; SM0805
R3, R6, R19, R34, R37: 10K; SM0805
R4, R5, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33: 0; SM0805
R35, R36: 100; SM0805
SW1: RESET; SW_PUSH_SMALL
SW2: MODE_ISP; SW_PUSH_SMALL
U1: LM317T; TO220_REG
U2: LPC1114FN28/201; DIP-28__600
U3: 74LVC125; SO14N
X1: 12 Mhz; HC-49V

Connections:
+3.3V: C4.1, C5.2, C6.1, D1.1 (A), R2.2, R3.2, R19.2, R34.2, R37.2, U1.2 (OUT), U2.7 (VDDA), U2.21 (VDD), U3.14 (VCC)
GND: C1.2, C2.1, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, CON1.2, CON1.3, P2.3, P2.5, P2.7, P2.9, P3.1, P3.2, R1.2, R6.1, R35.2, R36.2, U2.8 (VSSA), U2.22 (VSS), U3.2 (D), U3.5 (D), U3.7 (GND)
unnamed: R20.1, U2.1 (PIO0_8/MISO0/CT16B0_MAT0)
unnamed: R15.2, U2.12 (SWDIO/PIO1_3/AD4/CT32B1_MAT2)
unnamed: R14.2, U2.11 (R/PIO1_2/AD3/CT32B1_MAT1)
unnamed: R13.2, U2.10 (R/PIO1_1/AD2/CT32B1_MAT0)
unnamed: R12.2, U2.9 (R/PIO1_0/AD1/CT32B1_CAP0)
unnamed: R11.2, U2.4 (R/PIO0_11/AD0/CT32B0_MAT3)
unnamed: R10.2, U2.6 (PIO0_6/SCK0)
unnamed: R9.2, U2.5 (PIO0_5/SDA)
unnamed: R8.2, U2.27 (PIO0_4/SCL)
unnamed: R7.2, U2.3 (SWCLK/PIO0_10/SCK0/CT16B0_MAT2)
unnamed: R27.1, U2.17 (PIO1_8/CT16B1_CAP0)
unnamed: R26.1, U2.18 (PIO1_9/CT16B1_MAT0)
unnamed: R25.1, U2.26 (PIO0_3)
unnamed: R23.1, U2.24 (PIO0_1/CLKOUT/CT32B0_MAT2)
unnamed: R22.1, U2.25 (PIO0_2/SSEL0/CT16B0_CAP0)
unnamed: R21.1, U2.2 (PIO0_9/MOSI0/CT16B0_MAT1)
unnamed: R16.2, U2.13 (PIO1_4/AD5/CT32B1_MAT3/WAKEUP)
unnamed: CON1.1, K1.1
unnamed: R31.1, U2.14 (PIO1_5/RTS/CT32B0_CAP0)
unnamed: R30.1, U2.15 (PIO1_6/RXD/CT32B0_MAT0)
unnamed: R29.1, U2.16 (PIO1_7/TXD/CT32B0_MAT1)
unnamed: P4.4, R28.2
unnamed: R28.1, U2.28 (PIO0_7/~CTS~)
unnamed: P1.7, R13.1
unnamed: P4.1, R31.2
unnamed: P4.10, R22.2
unnamed: P4.11, R21.2
unnamed: P4.12, R20.2
unnamed: P1.10, R16.1
unnamed: P1.8, R14.1
unnamed: P3.5, P4.3, R29.2
unnamed: P1.6, R12.1
unnamed: P1.5, R11.1
unnamed: P1.4, R10.1
unnamed: P1.3, R9.1
unnamed: P1.2, R8.1
unnamed: R1.1, R2.1, U1.1 (ADJ)
unnamed: P3.6, P5.1
unnamed: P2.6, R37.1
unnamed: P3.4, P4.2, R30.2
unnamed: R33.2, U3.6 (O)
unnamed: R18.2, U3.3 (O)
unnamed: C8.1, R32.2, R33.1, R34.1, SW2.1
unnamed: R35.1, SW1.2
unnamed: P1.1, R5.2, R7.1
unnamed: P2.4, R5.1, R6.2
unnamed: C7.1, R17.2, R18.1, R19.1, SW1.1
unnamed: R24.1, U2.23 (~RESET~/PIO0_0)
unnamed: P4.7, R25.2
unnamed: P4.6, R26.2
unnamed: P4.5, R27.2
unnamed: P2.2, R3.1, R4.1
unnamed: R36.1, SW2.2
unnamed: P1.9, R4.2, R15.1
PROG_VCC: K1.3, P2.1, P3.3
RTS: P5.2 (PM), U3.1 (E), U3.4 (E)
XTALIN: C2.2, U2.20 (XTALIN), X1.2
XTALOUT: C3.2, U2.19 (XTALOUT), X1.1
~MODE_ISP: P4.9, R23.2, R32.1
~RESET: P2.10, P4.8, R17.1, R24.2

Notes on the sheet:
Vout = Vref*(1+(R2/R1))+ (Iadj*R2) Vout=1.25*(1+330/200))+(0.010*330)
1 GND (BLACK) 2 ~CTS~ (BROWN) 3 VCC (RED) 4 TXD (ORANGE) 5 RXD (YELLOW) 6 ~RTS~ (GREEN)
REGULATOR
1 VCC 2 SWDIO/TMS 3 GND 4 SWDCLK/TCK 5 GND 6 NC/TDI 7 KEY 8 SWO/TDO 9 GNDDetect 10 ~RESET
0.05" 2x5 header
0.1" 1x6 header
0.1" 1x12 header
OPTIONAL
3.3V Logic Levels
Jumper 1 to 2 to enable RESET via RTS line

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
Board: 2 copper layers, 101.6 x 50.8 mm, 59 parts (21 on the bottom side), 63 nets.

## Commit log

2014-06-13 Snapshot of V1 of LPC1114 dev board design
2014-06-13 Add README files
2014-06-15 Move power selection jumper after regulator
    Begin Version 1.1 changes
    Move power selection jumper after regulator
2014-06-20 Cleanup
    Clarify pitch of SWD connector
    Rework power options
    Add PWR/GND header connections
    Add power indicator LEDs
